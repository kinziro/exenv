Commit message: ur5のが掴めるようにブロックのサイズを修正

File: exenv/robotics/meshes/objects/cube_small.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=.03 .03 .03; visual mesh filename=cube.obj scale=.03 .03 .03
